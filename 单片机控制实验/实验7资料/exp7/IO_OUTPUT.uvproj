# Keil uVision project IO_OUTPUT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(33000000) MODAT2
  output: IO_OUTPUT +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\芮德华\EMCU\KEIL C51单片机实验(C语言版)\IO_INPUT\INCLUDE\
  group Source Group 1
    ./user/: main.c delay.c st7920.c tlc2543.c
